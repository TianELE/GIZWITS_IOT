# Keil uVision project ATK_AHT10.uvprojx, settings and files
target KS2020 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: test +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\WMLIB\include;..\WMLIB\include\armcc;..\WMLIB\include\driver;..\WMLIB\include\platform;..\WMLIB\platform\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\usart2;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDT;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\SPI;..\USMART;..\HARDWARE\RTC;..\HARDWARE\AHT10;..\HARDWARE\MYIIC;..\image;..\HARDWARE\AP3216C;..\Utils;..\Gizwits;..\HARDWARE\MYIIC2;..\HARDWARE\DS18B20;..\HARDWARE\CCS811;..\HARDWARE\IIC;..\HARDWARE\BEEP
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0xeff00
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x20028000 size 0x20000
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
  group WMLIB
    ../WMLIB/platform/boot/armcc/: startup.s misc.c
    ../WMLIB/platform/drivers/: wm_gpio.c wm_cpu.c wm_io.c wm_irq.c wm_pmu.c wm_timer.c wm_gpio_afsel.c wm_watchdog.c wm_pwm.c wm_hostspi.c wm_dma.c wm_rtc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/AHT10/: aht10.c aht10.h
    ../HARDWARE/MYIIC/: myiic.c myiic.h
    ../HARDWARE/WDT/: wdt.c wdt.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/usart2/: usart2.c usart2.h
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/MYIIC2/: myiic2.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/CCS811/: CCS811.c
    ../HARDWARE/IIC/: CCS811iic.c
    ../HARDWARE/BEEP/: beep.c
  group README
    ../: readme.txt
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_product.h gizwits_protocol.c gizwits_protocol.h
  group Utils
    ../Utils/: common.c common.h dataPointTools.c dataPointTools.h ringbuffer.c ringBuffer.h
  group image
    ../image/: image1.h image2.h image_wifi1.h image_wifi2.h image_h.h image_t.h image_als.h
